Commit message: bugfixes, raisim mrt starts to work

File: ocs2_robotic_examples/ocs2_ballbot_raisim_example/config/ballbot_raisim.urdf (robot description, URDF)
Before this commit: robot ballbot, 2 links, 1 joints
Joints:
- joint ballSuspension: origin xyz=0 0 -0.6 -> xyz=0 0 0
