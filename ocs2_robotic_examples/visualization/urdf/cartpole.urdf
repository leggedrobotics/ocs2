Commit message: Added the quadrotor visualizer

File: ocs2_robotic_examples/visualization/urdf/cartpole.urdf (robot description, URDF)
Before this commit: robot physics, 3 links, 2 joints
Links:
- link slideBar: geometry visual box size=300 0.05 0.05
